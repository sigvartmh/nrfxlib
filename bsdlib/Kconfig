## bsdlib/Kconfig
```kconfig
config BSD_LIB
	bool "Binary bsdlib"
	default y
	depends on BSD_LIBRARY
	select NRF_OBERON
	help
	  Redefinition of BSD_LIBRARY inside nrfxlib.
```
